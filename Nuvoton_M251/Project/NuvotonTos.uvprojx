# Keil uVision project NuvotonTos.uvprojx, settings and files
target Target 1 (6070000::V6.7::.\ARMCLANG)
  device: M251KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: NuvotonTos
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: ..\CMSIS;..\STARTUP;..\StdDriver\inc;..\TencentOS\arch\include;..\TencentOS\kernel\core\include;..\TencentOS\kernel\pm\include;..\TencentOS\TOS_CONFIG;..\TencentOS\arch;..\STARTUP\Include;..\Hardwear\Pid_control;..\Hardwear\ADC;..\Toilet_Driver\Temp_module;..\Toilet_Driver\Comm_module;..\Toilet_Driver\Temp_table;..\Toilet_Driver\Control_center;..\Hardwear\DWT_Delay;..\Hardwear\Timer;..\Toilet_Driver\Beep_module;..\Toilet_Driver\deodorzation_module;..\Toilet_Driver\Flush_module;..\Toilet_Driver\IR_module\IR_remote;..\Toilet_Driver\IR_module\IR_Cover;..\Toilet_Driver\Moto_module;..\Toilet_Driver\Sit_module
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../STARTUP/: system_M251.c startup_M251.s
  group StdDriver
    ../StdDriver/src/: clk.c retarget.c uart.c gpio.c sys.c eadc.c timer.c
  group USER
    ./: main.c
  group Tos/arch
    ../TencentOS/arch/: port_c.c tos_cpu.c tos_fault.c port_s.S
  group Tos/kernel
    ../TencentOS/kernel/core/: tos_event.c tos_fifo.c tos_global.c tos_mmblk.c tos_mmheap.c tos_msg.c tos_mutex.c tos_pend.c tos_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
    ../TencentOS/kernel/pm/: tos_pm.c tos_tickless.c
  group Tos/config
    ../TencentOS/TOS_CONFIG/: tos_config.h
  group Hardwear
    ../Hardwear/Pid_control/: PID_Lib.c PID_Lib_usr.c
    ../Hardwear/ADC/: adc.c
    ../Hardwear/DWT_Delay/: DWT_Delay.c
    ../Hardwear/Timer/: timer_deal.c
  group Toilet_driver
    ../Toilet_Driver/Temp_module/: temp_deal.c
    ../Toilet_Driver/Comm_module/: toilet.h
    ../Toilet_Driver/Temp_table/: table.c
    ../Toilet_Driver/Control_center/: control_center.c
    ../Toilet_Driver/Beep_module/: beep.c
    ../Toilet_Driver/deodorzation_module/: deodorzation.c
    ../Toilet_Driver/Flush_module/: flush.c
    ../Toilet_Driver/IR_module/IR_remote/: IR_remote.c
    ../Toilet_Driver/IR_module/IR_Cover/: IR_cover.c
    ../Toilet_Driver/Moto_module/: Moto_deal.c
    ../Toilet_Driver/Sit_module/: sit_check.c
software components: CMSIS:CORE 5.0.1
